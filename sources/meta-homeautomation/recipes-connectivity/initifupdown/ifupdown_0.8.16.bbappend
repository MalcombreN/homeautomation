DESCRIPTION = "override clasic interfaces configuration file"
SECTION = "networks.inc"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
