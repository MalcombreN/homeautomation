DESCRIPTION = "override clasic openssh server's configuration file"
SECTION = "server-openssh.inc"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
