SUMMARY = "A small image for a homeautomation box."
LICENSE = "MIT"

inherit core-image
