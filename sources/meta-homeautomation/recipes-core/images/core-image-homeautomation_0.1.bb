include recipes-core/images/core-image-minimal.bb

inherit rm_work
