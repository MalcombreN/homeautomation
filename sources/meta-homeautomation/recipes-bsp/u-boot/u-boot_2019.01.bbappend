FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-CONFIG_OF_SEPARATE-in-include-configs-rpi.h.patch"

